<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rtty_decode</value></param>
<param><key>author</key><value>Chris Kuethe</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>RTTY decoder example</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bps</value></param>
<param><key>value</key><value>45.45</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>8000</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>0.75</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>0.25</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>gr_file_sink_0</value></param>
<param><key>append</key><value>True</value></param>
<param><key>file</key><value>/tmp/rtty-out.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>hilbert_fc</key>
<param><key>id</key><value>gr_hilbert_fc_0</value></param>
<param><key>num_taps</key><value>65</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>gr_moving_average_xx_0</value></param>
<param><key>length</key><value>2*samp_rate/decimation</value></param>
<param><key>max_iter</key><value>samp_rate/decimation</value></param>
<param><key>scale</key><value>1.0/(2*samp_rate/decimation)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>gr_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>4</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>gr_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>bps*3</value></param>
<param><key>decim</key><value>decimation</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>4</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>bps</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>n_gain</value></param>
<param><key>note</key><value>Adjust gain to get nice clean signal coming out of the LPF</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>n_levels</value></param>
<param><key>note</key><value>adjust moving average and threshold to get clean 0/1 out</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>n_ma</value></param>
<param><key>note</key><value>Keep product of length and scale close to 1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>n_rtty_bitstream</value></param>
<param><key>note</key><value>It may be necessary to flip the bitstream polarity</value></param>
</block>
<block>
<key>rtty_decode_ff</key>
<param><key>id</key><value>rtty_decode_ff_0</value></param>
<param><key>baud_rate</key><value>bps</value></param>
<param><key>polarity</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate/decimation</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>baseband</value></param>
</block>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>rtty_decode_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_hilbert_fc_0</source_block_id><sink_block_id>gr_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_moving_average_xx_0</source_block_id><sink_block_id>gr_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_quadrature_demod_cf_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_sub_xx_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>gr_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>gr_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtty_decode_ff_0</source_block_id><sink_block_id>gr_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>gr_hilbert_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
